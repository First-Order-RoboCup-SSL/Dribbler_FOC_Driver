# Repository First-Order-RoboCup-SSL/Dribbler_FOC_Driver

File README.md:

# Dribbler_FOC_Driver
FOC Driver

Version 1

## KiCad design dribbler_driver_ver.6/dribbler_driver.kicad_pcb

Parts:
C1, C35, C41: 22uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C6, C7, C8, C9, C10, C33, C68: 100n; C_0603_1608Metric
C3, C5: 2n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C11, C51, C59: 4u7; C_0603_1608Metric
C12, C19: 6p; C_0603_1608Metric
C13, C15, C17, C22, C23, C24, C38: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C16: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C18, C20, C25, C27: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C57: 10n; C_0603_1608Metric
D1: ESD1CAN; SOT-23
D2, D6, D7, D8: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3, D4, D5: 1N5819WS; D_SOD-323_HandSoldering; Manufacturer Part 1N5819WS
H1, H2: MountingHole; MountingHole_3.2mm_M3_Pad
J1: Conn_01x04_MountingPin; Molex_PicoBlade_53261-0471_1x04-1MP_P1.25mm_Horizontal
J2, J8: Conn_01x03_MountingPin; JST_GH_BM03B-GHS-TBT_1x03-1MP_P1.25mm_Vertical
J3, J4, J7: Conn_01x02_MountingPin; JST_GH_BM02B-GHS-TBT_1x02-1MP_P1.25mm_Vertical
J5: Conn_01x02_Pin; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J6: Conn_01x08_MountingPin; JST_PH_S8B-PH-SM4-TB_1x08-1MP_P2.00mm_Horizontal
L2: 4.7uH; L_Changjiang_FNR4020S
Q1, Q2, Q5, Q6, Q9, Q10: WSD4070DN; DFN-8-1EP_3x3mm_P0.5mm_EP1.65x2.38mm; Manufacturer Part WSD4070DN
R1: 120R; R_0603_1608Metric
R2, R4, R6: 4.7kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R5, R9: 100Ω; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R8: 0.01Ω; R_1206_3216Metric
R10: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12, R13, R14, R15, R20: 2.2Ω; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16, R17, R21, R22, R23, R24, R28, R29, R30: 10kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R19: 470Ω; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R26: 47kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R27: 249kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R33, R34: 1kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R35: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R41: 100k; R_0603_1608Metric
SW1, SW2: SW_Push; SW_SPST_SKQG_WithoutStem
U2, U3: INA240A2PWR; TSSOP-8_4.4x3mm_P0.65mm; Manufacturer Part INA240A2PWR
U4: TJA1042T-3; SOIC-8_3.9x4.9mm_P1.27mm
U5: RY8411; SOT-23-6_Handsoldering
U8: EG2133; TSSOP-20-1EP_4.4x6.5mm_P0.65mm_EP2.15x3.35mm; Manufacturer Part EG2133
U10: RS3236; SOT-23-5
U12: STM32G431CBUx; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm
Y1: CX3225GB16000D0HEQCC; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C7.1, C8.1, C9.1, C10.1, C11.1, C13.1, C15.1, C59.1, C68.1, J1.4, J2.1, J6.5, R2.2, R4.2, R6.2, R34.1, R35.2, U2.5 (VS), U2.6 (REF2), U3.5 (VS), U3.6 (REF2), U4.5 (VIO), U10.5 (VOUT), U12.1 (VBAT), U12.20 (VREF+), U12.21 (VDDA), U12.23 (VDD), U12.35 (VDD), U12.48 (VDD)
+5V: C1.1, C16.1, C17.1, C33.1, C35.1, C51.1, D3.2 (A), D4.2 (A), D5.2 (A), J7.1, L2.1, R27.2, R33.1, U4.3 (VCC), U8.7 (VCC), U10.1 (VIN), U10.3 (ON/~OFF)
+24V: C18.1, C20.1, C25.1, C27.1, C41.1, J5.2, Q1.5 (D), Q1.6 (D), Q1.7 (D), Q1.8 (D), Q1.9 (D), Q5.5 (D), Q5.6 (D), Q5.7 (D), Q5.8 (D), Q5.9 (D), Q9.5 (D), Q9.6 (D), Q9.7 (D), Q9.8 (D), Q9.9 (D), R10.1, U5.4 (EN), U5.5 (IN)
/M0_GH1: R12.2, U8.19 (HO1)
/M0_GH2: R11.2, U8.16 (HO2)
/M0_GH3: R20.2, U8.13 (HO3)
/M0_GL1: R13.2, U8.11 (LO1)
/M0_GL2: R14.2, U8.10 (LO2)
/M0_GL3: R15.2, U8.9 (LO3)
/M0_OUT1_P: C22.1, U8.18 (VS1)
/M0_OUT2_CS: U3.8 (OUT), U12.15 (PA7)
/M0_OUT2_P: C23.1, Q5.1 (S), Q5.2 (S), Q5.3 (S), Q6.5 (D), Q6.6 (D), Q6.7 (D), Q6.8 (D), Q6.9 (D), R8.1, R22.1, U3.3 (IN-), U8.15 (VS2)
/M0_OUT3: C24.1, U8.12 (VS3)
/M0_OUT3_CS: U2.8 (OUT), U12.14 (PA6)
/M0_OUT3_P: Q9.1 (S), Q9.2 (S), Q9.3 (S), Q10.5 (D), Q10.6 (D), Q10.7 (D), Q10.8 (D), Q10.9 (D), R7.1, R24.1, U2.3 (IN-)
/XTAL_1: C12.1, U12.5 (PF0), Y1.1
/XTAL_2: C19.1, U12.6 (PF1), Y1.3
CANH: D1.1 (K), J3.2, J4.2, R1.1, U4.7 (CANH)
CANL: D1.2 (K), J3.1, J4.1, R1.2, U4.6 (CANL)
CAN_RX: U4.4 (RXD), U12.33 (PA11)
CAN_TX: U4.1 (TXD), U12.34 (PA12)
DBG: C6.1, R35.1, SW2.1, U12.38 (PA15)
GND: C1.2, C2.2, C3.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C25.2, C27.2, C33.2, C35.2, C41.2, C51.2, C57.2, C59.2, C68.2, D1.3 (A), D2.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), H1.1, H2.1, J1.3, J1.MP (MountPin), J2.2, J2.MP (MountPin), J3.MP (MountPin), J4.MP (MountPin), J5.1, J6.4, J6.MP (MountPin), J7.MP (MountPin), J8.3, J8.MP (MountPin), Q2.1 (S), Q2.2 (S), Q2.3 (S), Q6.1 (S), Q6.2 (S), Q6.3 (S), Q10.1 (S), Q10.2 (S), Q10.3 (S), R17.1, R21.1, R23.1, R26.1, R28.1, R29.1, R30.1, R41.1, SW1.2, SW2.2, U2.4 (GND), U2.7 (REF1), U3.4 (GND), U3.7 (REF1), U4.2 (GND), U4.8 (STB), U5.2 (GND), U8.8 (GND), U8.21, U10.2 (GND), U12.49 (VSS), Y1.2, Y1.4; also elsewhere on the board
HALL_A: J6.3, R6.1, R9.1
HALL_A_OUT: C5.1, R9.2, U12.10 (PA2)
HALL_B: J6.2, R4.1, R5.1
HALL_C: J6.1, R2.1, R3.1
HALL_C_OUT: C3.2, R3.2, U12.8 (PA0)
HALL_SENSE1: J2.3, U12.25 (PB12)
HALL_SENSE2: J7.2, U12.27 (PB14)
LED_1: R19.2, U12.39 (PC10)
M0_IN1: R30.2, U8.1 (HIN1), U8.4 (LIN1#), U12.30 (PA8)
M0_IN2: R29.2, U8.2 (HIN2), U8.5 (LIN2#), U12.31 (PA9)
M0_IN3: R28.2, U8.3 (HIN3), U8.6 (LIN3#), U12.29 (PC6)
M0_OUT1: J6.8, Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.5 (D), Q2.6 (D), Q2.7 (D), Q2.8 (D), Q2.9 (D), R16.1
M0_OUT2_N: J6.7, R8.2, U3.2 (IN+)
M0_OUT3_N: J6.6, R7.2, U2.2 (IN+)
unnamed: D2.2 (A), R19.1
unnamed: C22.2, D3.1 (C), U8.20 (VB1)
unnamed: C23.2, D4.1 (C), U8.17 (VB2)
unnamed: C24.2, D5.1 (C), U8.14 (VB3)
unnamed: D6.2 (A), R33.2
unnamed: D7.2 (A), R34.2
unnamed: D8.2 (A), R10.2
unnamed: Q1.4 (G), R12.1, R16.2
unnamed: Q2.4 (G), R13.1, R17.2
unnamed: Q5.4 (G), R11.1, R22.2
unnamed: Q6.4 (G), R14.1, R21.2
unnamed: Q9.4 (G), R20.1, R24.2
unnamed: Q10.4 (G), R15.1, R23.2
unnamed: C38.2, U5.1 (BS)
unnamed: R26.2, R27.1, U5.3 (FB)
unnamed: C57.1, U10.4 (BP)
unnamed: R41.2, U12.46 (PB8)
SW: C38.1, L2.2, U5.6 (SW)
SWCLK: J1.2, U12.37 (PA14)
SWDIO: J1.1, U12.36 (PA13)
USART2_RX: J8.2, U12.24 (PB11)
USART2_TX: J8.1, U12.22 (PB10)

Notes on the sheet:
GH1.25
for GPIO Debugging

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
Board: 4 copper layers, 77.7 x 32.1 mm, 99 parts (2 on the bottom side), 61 nets.

Other parts of the board:
C4: 0.01u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder

Their connections:
GND: C4.2; also elsewhere on the board

File dribbler_driver_ver.6/foc_driver_BOM.xlsx:

Reference | Value | Datasheet | Footprint | Qty | DNP
C1,C29,C40 | 100uF | ~ | Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder | 3
C2 | 1u | ~ | Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder | 1
C3,C4,C5,C6 | 0.01u | ~ | Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder | 4
C10,C11,C12,C13,C15,C19 | 4.7uF | ~ | Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder | 6
C14,C17,C22,C23,C24,C26,C36,C38,C39 | 100nF | ~ | Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder | 9
C16 | 1uF | ~ | Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder | 1
C18,C20,C25,C27 | 10u | ~ | Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder | 4
C21,C28 | 20pF | ~ | Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder | 2
C34,C35,C41,C42 | 10uF | ~ | Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder | 4
C37 | 30pF | ~ | Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder | 1
R1 | 0 |  | Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder | 1
R2,R4,R6 | 4.7k | ~ | Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder | 3
R3,R5,R9 | 100 | ~ | Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder | 3
R7,R8 | 0.01 | ~ | Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder | 2
R10 | 1k | ~ | Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder | 1
R11,R12,R13,R14,R15,R20 | 2.2000000000000002 | ~ | Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder | 6
R16,R17,R21,R22,R23,R24,R28,R29,R30 | 10k | ~ | Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder | 9
R18 | 120 | ~ | Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder | 1
R19 | 470 | ~ | Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder | 1
R25 | 100k | ~ | Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder | 1
R26 | 47k | ~ | Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder | 1
R27 | 249k | ~ | Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder | 1
RN2 | R_Pack04_SIP_Split | http://www.vishay.com/docs/31509/csc.pdf | R_array_4:0402*4_r | 1
L2 | 15uH | ~ | Inductor_SMD:L_Neosid_SM-NE127_HandSoldering | 1

## KiCad design dribbler_driver_ver.5.3/dribbler_driver.kicad_pcb

Parts:
C1, C35, C41: 22uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C4, C5, C6, C19: 0.01u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8, C9, C10, C11, C12, C13, C14, C15, C17, C22, C23, C24, C26, C38: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C16: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C18, C20, C25, C27: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C21, C28: 20p; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
D1: BZT52B20-G; D_SOD-323
D2: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3, D4, D5: 1N5819WS; D_SOD-323_HandSoldering; Manufacturer Part 1N5819WS
D6, D7, D8: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Manufacturer Part 17-21SUYC/TR8
H1, H2: MountingHole; MountingHole_3.2mm_M3_Pad
J1: Conn_01x04_Pin; Molex_PicoBlade_53261-0471_1x04-1MP_P1.25mm_Horizontal
J3, J4: Conn_01x02_MountingPin; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal
J5: Conn_01x02_Pin; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J6: Conn_01x08_Socket; JST_PH_S8B-PH-SM4-TB_1x08-1MP_P2.00mm_Horizontal
L2: 4.7uH; L_Changjiang_FNR4020S
Q1, Q2, Q5, Q6, Q9, Q10: WSD4070DN; DFN-8-1EP_3x3mm_P0.5mm_EP1.65x2.38mm; Manufacturer Part WSD4070DN
R2, R4, R6: 4.7kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R5, R9: 100Ω; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R8: 0.01Ω; R_1206_3216Metric
R10: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12, R13, R14, R15, R20: 2.2Ω; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16, R17, R21, R22, R23, R24, R28, R29, R30: 10kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R18: 120Ω; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R19: 470Ω; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R26: 47kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R27: 249kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R31, R32, R35: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R33, R34: 1kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RY8411: SOT-23-6_Handsoldering
SW1, SW2: SW_Push; SW_SPST_SKQG_WithoutStem
U1: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U2, U3: INA240A2PWR; TSSOP-8_4.4x3mm_P0.65mm; Manufacturer Part INA240A2PWR
U5: SIT1042T; SOP-8_3.9x4.9mm_P1.27mm
U6: XC6210B332MR; SOT-23-5
U8: EG2133; TSSOP-20-1EP_4.4x6.5mm_P0.65mm_EP2.15x3.35mm; Manufacturer Part EG2133
USART1: Conn_01x03; JST_GH_SM03B-GHS-TB_1x03-1MP_P1.25mm_Horizontal
Y2: 16MHz; Crystal_SMD_SeikoEpson_TSX3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C2.2, C7.1, C9.1, C10.1, C11.1, C12.1, C13.1, C15.1, J1.1, R2.2, R4.2, R6.2, R32.2, R34.1, R35.2, U1.1 (VBAT), U1.9 (VDDA), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U2.5 (VS), U2.6 (REF2), U3.5 (VS), U3.6 (REF2), U6.5 (VOUT)
+5V: C1.1, C6.2, C16.1, C17.1, C26.2, C35.1, D1.1 (K), D3.2 (A), D4.2 (A), D5.2 (A), J6.8, L2.1, R27.2, R33.1, U5.3 (VCC), U6.1 (VIN), U6.3 (CE), U8.7 (VCC)
+24V: C18.1, C20.1, C25.1, C27.1, C41.1, J5.2, Q1.5 (D), Q1.6 (D), Q1.7 (D), Q1.8 (D), Q1.9 (D), Q5.5 (D), Q5.6 (D), Q5.7 (D), Q5.8 (D), Q5.9 (D), Q9.5 (D), Q9.6 (D), Q9.7 (D), Q9.8 (D), Q9.9 (D), R10.1, RY8411.4 (EN), RY8411.5 (IN)
/M0_GH1: R12.2, U8.19 (HO1)
/M0_GH2: R11.2, U8.16 (HO2)
/M0_GH3: R20.2, U8.13 (HO3)
/M0_GL1: R13.2, U8.11 (LO1)
/M0_GL2: R14.2, U8.10 (LO2)
/M0_GL3: R15.2, U8.9 (LO3)
/M0_OUT1_P: C22.1, U8.18 (VS1)
/M0_OUT2_CS: U1.33 (PA12), U3.8 (OUT)
/M0_OUT2_P: C23.1, Q5.1 (S), Q5.2 (S), Q5.3 (S), Q6.5 (D), Q6.6 (D), Q6.7 (D), Q6.8 (D), Q6.9 (D), R8.1, R22.1, U3.3 (IN-), U8.15 (VS2)
/M0_OUT3: C24.1, U8.12 (VS3)
/M0_OUT3_CS: U1.32 (PA11), U2.8 (OUT)
/M0_OUT3_P: Q9.1 (S), Q9.2 (S), Q9.3 (S), Q10.5 (D), Q10.6 (D), Q10.7 (D), Q10.8 (D), Q10.9 (D), R7.1, R24.1, U2.3 (IN-)
CANH: J3.2, J4.2, R18.1, U5.7 (CANH)
CANL: J3.1, J4.1, R18.2, U5.6 (CANL)
CAN_RX: U1.45 (PB8), U5.4 (RXD)
CAN_TX: U1.46 (PB9), U5.1 (TXD)
DBG: R35.1, SW2.1, U1.26 (PB13)
GND: C1.2, C2.1, C3.1, C4.2, C5.2, C6.1, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.1, C20.2, C21.2, C25.2, C26.1, C27.2, C28.2, C35.2, C41.2, D1.2 (A), D2.1 (K), D6.1 (-), D7.1 (-), D8.1 (-), H1.1, H2.1, J1.4, J3.MP (MountPin), J4.MP (MountPin), J5.1, J6.7, Q2.1 (S), Q2.2 (S), Q2.3 (S), Q6.1 (S), Q6.2 (S), Q6.3 (S), Q10.1 (S), Q10.2 (S), Q10.3 (S), R17.1, R21.1, R23.1, R26.1, R28.1, R29.1, R30.1, R31.1, RY8411.2 (GND), SW1.2, SW2.2, U1.8 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U2.4 (GND), U2.7 (REF1), U3.4 (GND), U3.7 (REF1), U5.2 (GND), U5.8 (STB), U6.2 (GND), U8.8 (GND), USART1.3
HALL_A: J6.1, R2.1, R3.1
HALL_B: J6.2, R4.1, R5.1
HALL_C: J6.3, R6.1, R9.1
LED_1: R19.2, U1.27 (PB14)
M0_IN1: R30.2, U1.16 (PA6), U8.1 (HIN1), U8.4 (LIN1#)
M0_IN2: R29.2, U1.17 (PA7), U8.2 (HIN2), U8.5 (LIN2#)
M0_IN3: R28.2, U1.31 (PA10), U8.3 (HIN3), U8.6 (LIN3#)
M0_OUT1: J6.6, Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.5 (D), Q2.6 (D), Q2.7 (D), Q2.8 (D), Q2.9 (D), R16.1
M0_OUT2_N: J6.5, R8.2, U3.2 (IN+)
M0_OUT3_N: J6.4, R7.2, U2.2 (IN+)
NRST: C8.1, R32.1, SW1.1, U1.7 (NRST)
unnamed: D2.2 (A), R19.1
unnamed: C22.2, D3.1 (C), U8.20 (VB1)
unnamed: C23.2, D4.1 (C), U8.17 (VB2)
unnamed: C24.2, D5.1 (C), U8.14 (VB3)
unnamed: D6.2 (+), R10.2
unnamed: D7.2 (+), R33.2
unnamed: D8.2 (+), R34.2
unnamed: Q1.4 (G), R12.1, R16.2
unnamed: Q2.4 (G), R13.1, R17.2
unnamed: Q5.4 (G), R11.1, R22.2
unnamed: Q6.4 (G), R14.1, R21.2
unnamed: Q9.4 (G), R20.1, R24.2
unnamed: Q10.4 (G), R15.1, R23.2
unnamed: C38.2, RY8411.1 (BS)
unnamed: R26.2, R27.1, RY8411.3 (FB)
unnamed: R31.2, U1.44 (BOOT0)
unnamed: C3.2, R3.2, U1.41 (PB5)
unnamed: C4.1, R5.2, U1.42 (PB6)
unnamed: C5.1, R9.2, U1.43 (PB7)
unnamed: C14.1, U5.5 (SPLIT)
unnamed: C19.2, U6.4 (BP)
unnamed: Y2.2, Y2.3
RCC_OSC_IN+: C21.1, U1.5 (PD0), Y2.1
RCC_OSC_OUT-: C28.1, U1.6 (PD1), Y2.4
SW: C38.1, L2.2, RY8411.6 (SW)
SYS_JTCK_SWCLK: J1.3, U1.37 (PA14)
SYS_JTMS_SWDIO: J1.2, U1.34 (PA13)
USART2_RX: U1.13 (PA3), USART1.1
USART2_TX: U1.12 (PA2), USART1.2

Notes on the sheet:
GH1.25
LDO降压
for GPIO Debugging

Board: 4 copper layers, 77.7 x 32.1 mm, 96 parts (2 on the bottom side), 61 nets.

File dribbler_driver_ver.5.3/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C35, C41",0603,3,22uF,
"C10, C11, C12, C13, C14, C15, C17, C22, C23, C24, C26, C38, C8, C9",0603,14,100nF,
C16,0603,1,1uF,
"C18, C20, C25, C27",0603,4,10u,
"C19, C3, C4, C5, C6",0603,5,0.01u,
C2,0603,1,1u,
"C21, C28",0603,2,20p,
C7,0603,1,4.7uF,
D1,D_SOD-323,1,BZT52B20-G,
"D2, D6, D7, D8",0603,4,LED,
"D3, D4, D5",D_SOD-323_HandSoldering,3,1N5819WS,
J1,Molex_PicoBlade_53261-0471_1x04-1MP_P1.25mm_Horizontal,1,Conn_01x04_Pin,
"J3, J4",JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal,2,Conn_01x02_MountingPin,
J5,AMASS_XT30U-M_1x02_P5.0mm_Vertical,1,Conn_01x02_Pin,
J6,JST_PH_S8B-PH-SM4-TB_1x08-1MP_P2.00mm_Horizontal,1,Conn_01x08_Socket,
L2,L_Changjiang_FNR4020S,1,4.7uH,
"Q1, Q10, Q2, Q5, Q6, Q9",DFN-8-1EP_3x3mm_P0.5mm_EP1.65x2.38mm,6,WSD4070DN,
"R10, R31, R32, R35",0603,4,10k,
"R11, R12, R13, R14, R15, R20",0603,6,2.2Ω,
"R16, R17, R21, R22, R23, R24, R28, R29, R30",0603,9,10kΩ,
R18,0603,1,120Ω,
R19,0603,1,470Ω,
"R2, R4, R6",0603,3,4.7kΩ,
R26,0603,1,47kΩ,
R27,0603,1,249kΩ,
"R3, R5, R9",0603,3,100Ω,
"R33, R34",0603,2,1kΩ,
"R7, R8",1206,2,0.01Ω,
RY8411,SOT-23-6_Handsoldering,1,~,
"SW1, SW2",SW_SPST_SKQG_WithoutStem,2,SW_Push,
U1,LQFP-48_7x7mm_P0.5mm,1,STM32F103C8Tx,
"U2, U3",TSSOP-8_4.4x3mm_P0.65mm,2,INA240A2PWR,
U5,SOP-8_3.9x4.9mm_P1.27mm,1,SIT1042T,
U6,SOT-23-5,1,XC6210B332MR,
U8,TSSOP-20-1EP_4.4x6.5mm_P0.65mm_EP2.15x3.35mm,1,EG2133,
USART1,JST_GH_SM03B-GHS-TB_1x03-1MP_P1.25mm_Horizontal,1,Conn_01x03,
Y2,Crystal_SMD_SeikoEpson_TSX3225-4Pin_3.2x2.5mm,1,16MHz,

## KiCad design V3P原理图和PCB最新_灯哥/SCH_DengFOC V3 pro/SCH_DengFOC V3 pro.kicad_pcb

Board: 4 copper layers, 56.3 x 39.5 mm, 102 parts (4 on the bottom side), 72 nets.

Parts:
C1, C2, C4, C5, C10, C12, C14, C15, C17, C24, C26, C27, C28, C33, C34: 0603
C3, C7, C8, C11, C18, C19, C25, C30, C31, C32: 0805
C9, C13, C16, C21, C23, C29: 0402
C35, C36: CAP-SMD_BD6.3-L6.6-W6.6-LS7.4-FD
D2: DO-214AC_L4.3-W2.7-LS5.3-RD
D4, D6, D7, D8, D9, D10, D11: SOD-323_L1.8-W1.3-LS2.5-RD
H1: HDR-TH_18P-P2.54-V-R2-C9-S2.54
H2, H3: SMD,P=2.54mm(交错脚)
L1: IND-SMD_L5.0-W5.0_SWPA5040S
LED1: LED0805-RD
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12: PDFN3333-8_L3.1-W3.2-P0.65-LS3.4-BL
R2, R3: 0805
R4, R5, R6, R9, R10: 0603
R11, R12, R13, R14, R20, R21, R22, R23, R24, R25, R26, R27: 0402
R15, R16, R17, R18: R1206
R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39: R0402
U2: MICROPYTHON ESP32
U3: SOIC-8_L5.0-W4.0-P1.27-LS6.0-BL-EP
U5, U11: TSSOP-20_L6.5-W4.4-P0.65-LS6.4-BL
U6, U7, U8, U9: TSSOP-8_L4.4-W3.0-P0.65-LS6.4-BL
U10: SOT-223-4_L6.5-W3.5-P2.30-LS7.0-BR

Connections:
3V3: C26.1, C28.2, D11.2, H1.4, H1.11, H1.12, R3.1, U6.5, U6.6, U7.5, U7.6, U8.5, U8.6, U9.5, U9.6, U10.2, U10.4
5V: C1.2, C2.2, C4.1, C5.1, C24.1, C27.2, C33.2, C34.2, D4.2, D6.2, D7.2, D8.2, D9.2, D10.2, H1.18, L1.2, R9.2, U5.7, U10.3, U11.7
$1N75: LED1.2, R3.2
$1N530: R9.1, R10.2, U3.5
$1N531: C17.1, D2.1, L1.1, U3.8
$1N532: C17.2, U3.1
$1N535: C14.2, C15.2, U3.6
$1N536: C12.2, U3.4
$1N538: R4.1, R5.2, U3.3
$1N1312: C23.1, D9.1, U11.17
$1N1315: C29.1, D8.1, U11.14
$1N1336: C21.1, D10.1, U11.20
$1N1359: C9.1, D4.1, U5.20
$1N1370: C16.1, D7.1, U5.14
$1N1373: C13.1, D6.1, U5.17
$1N1444: C14.1, R6.2
$1N6010: Q7.4, R14.2, R34.1
$1N6048: Q8.4, R13.2, R35.1
$1N6067: Q9.4, R11.2, R36.1
$1N6091: Q10.4, R12.2, R37.1
$1N6102: Q12.4, R20.2, R38.1
$1N6136: Q11.4, R21.2, R39.1
$1N6143: Q6.4, R23.2, R33.1
$1N6154: Q5.4, R22.2, R32.1
$1N6178: Q4.4, R25.2, R30.1
$1N6189: Q3.4, R24.2, R31.1
$1N6225: Q2.4, R26.2, R29.1
$1N6232: Q1.4, R27.2, R28.1
$1N7980: D11.1, H2.1
GND: C1.1, C2.1, C3.1, C4.2, C5.2, C8.1, C10.2, C12.1, C15.1, C24.2, C26.2, C27.1, C28.1, C33.1, C34.1, D2.2, H1.3, H1.13, H1.14, H1.15, H1.16, H1.17, H3.13, LED1.1, R2.2, R5.1, R6.1, R10.1, U3.7, U3.9, U5.8, U6.4, U6.7, U7.4, U7.7, U8.4, U8.7, U9.4, U9.7, U10.1, U11.8
I_0: H1.9, H2.12
I_1: H1.10, H2.13
M0_GH1: R27.1, U11.19
M0_GH2: R24.1, U11.16
M0_GH3: R22.1, U11.13
M0_GL1: R26.1, U11.11
M0_GL2: R25.1, U11.10
M0_GL3: R23.1, U11.9
M0_IN1: H3.6, U11.1, U11.4
M0_IN2: H3.7, U11.2, U11.5
M0_IN3: H3.8, U11.3, U11.6
M0_OUT1_CS: H3.2, U6.8
M0_OUT1_N: R15.2, U6.2
M0_OUT1_P: C21.2, Q1.1, Q1.2, Q1.3, Q2.5, Q2.6, Q2.7, Q2.8, Q2.9, R15.1, R28.2, U6.3, U11.18
M0_OUT2_CS: H3.1, U7.8
M0_OUT2_N: R16.2, U7.2
M0_OUT2_P: C23.2, Q3.1, Q3.2, Q3.3, Q4.5, Q4.6, Q4.7, Q4.8, Q4.9, R16.1, R31.2, U7.3, U11.15
M0_OUT3: C29.2, Q5.1, Q5.2, Q5.3, Q6.5, Q6.6, Q6.7, Q6.8, Q6.9, R32.2, U11.12
M1_GH1: R14.1, U5.19
M1_GH2: R11.1, U5.16
M1_GH3: R21.1, U5.13
M1_GL1: R13.1, U5.11
M1_GL2: R12.1, U5.10
M1_GL3: R20.1, U5.9
M1_IN1: H3.9, U5.1, U5.4
M1_IN2: H3.10, U5.2, U5.5
M1_IN3: H3.11, U5.3, U5.6
M1_OUT1_CS: H3.5, U8.8
M1_OUT1_N: R17.2, U8.2
M1_OUT1_P: C9.2, Q7.1, Q7.2, Q7.3, Q8.5, Q8.6, Q8.7, Q8.8, Q8.9, R17.1, R34.2, U5.18, U8.3
M1_OUT2_CS: H3.4, U9.8
M1_OUT2_N: R18.2, U9.2
M1_OUT2_P: C13.2, Q9.1, Q9.2, Q9.3, Q10.5, Q10.6, Q10.7, Q10.8, Q10.9, R18.1, R36.2, U5.15, U9.3
M1_OUT3: C16.2, Q11.1, Q11.2, Q11.3, Q12.5, Q12.6, Q12.7, Q12.8, Q12.9, R39.2, U5.12
PGND: C7.1, C11.1, C18.1, C19.1, C25.1, C30.1, C31.1, C32.1, C35.2, C36.2, Q2.1, Q2.2, Q2.3, Q4.1, Q4.2, Q4.3, Q6.1, Q6.2, Q6.3, Q8.1, Q8.2, Q8.3, Q10.1, Q10.2, Q10.3, Q12.1, Q12.2, Q12.3, R2.1, R29.2, R30.2, R33.2, R35.2, R37.2, R38.2
RXD: H1.2, H2.8
SCL_0: H1.7, H2.5
SCL_1: H1.8, H2.6
SDA_0: H1.5, H2.3
SDA_1: H1.6, H2.4
TXD: H1.1, H2.7
VIN: C3.2, C7.2, C8.2, C10.1, C11.2, C18.2, C19.2, C25.2, C30.2, C31.2, C32.2, C35.1, C36.1, Q1.5, Q1.6, Q1.7, Q1.8, Q1.9, Q3.5, Q3.6, Q3.7, Q3.8, Q3.9, Q5.5, Q5.6, Q5.7, Q5.8, Q5.9, Q7.5, Q7.6, Q7.7, Q7.8, Q7.9, Q9.5, Q9.6, Q9.7, Q9.8, Q9.9, Q11.5, Q11.6, Q11.7, Q11.8, Q11.9, R4.2, U3.2

## Commit log

2025-03-21 Version 1 foc driver
2025-03-29 fixed stm32 peripherals
2025-03-31 version 4 of hardware
2025-04-02 updated pcb (GND network unprocessed)
2025-04-02 updated RY8411 footprint
2025-04-02 footprint RY8411 updated
2025-11-01 clean up
2025-11-01 clean up and update IOC
2025-12-27 fix mosfet solderability, High current path issue, update MCU
2026-01-09 gen 6 production
